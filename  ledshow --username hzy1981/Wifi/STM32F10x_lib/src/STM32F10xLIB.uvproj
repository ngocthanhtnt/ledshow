# Keil uVision project STM32F10xLIB.uvproj, settings and files
target STM32 Library - Release (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32F10x (library)
  AfterMake: cmd.exe /C copy .\Release\STM32F10x.LIB ..\STM32F10xR.LIB
  c flags: OneElfS=1 wLevel=2
  c include: ..\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Files
    ./: cortexm3_macro.s stm32f10x_lib.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ./USB/: STM32F10xR.lib
target STM32 Library - Debug (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: as above
  output: STM32F10x (library)
  AfterMake: cmd.exe /C copy .\Debug\STM32F10x.LIB ..\STM32F10xD.LIB
  c flags: Optim=1 OneElfS=1
  c define: DEBUG
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
