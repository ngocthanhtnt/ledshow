# Keil uVision project wpa_nodev_no2640.uvproj, settings and files
target wifi (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: wifi +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: IEEE8021X_EAPOL,OS_NO_C_LIB_DEFINES,CONFIG_PEERKEY,CONFIG_IEEE80211W,CONFIG_IEEE80211R,xCLOSE_WPA_LIMIT
  c include: ..\lwIP\src\include;..\lwIP\port\include;..\lwIP\src\include\ipv4;..\target;..\netapp;..\marvel\driver\inc;..\marvel\wpa\inc;..\sdio\inc;..\main;..\STM32F10x_lib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Start Up
    ../target/: STM32F10x.s
  group target
    ../target/: stm32f10x_it.c system.c
  group library
    ../STM32F10x_lib/: STM32F10xR.LIB
  group sdio
    ../sdio/src/: common.c core.c s3cmci.c sdio.c sdio_cis.c
    ../marvel/driver/src/8686_image/: help.c
  group marvell
    ../marvel/driver/src/: 11d.c assoc.c help_firmware.c if_sdio.c marvel8385_firmware.c marvell_ops.c scan.c
    ../marvel/driver/src/8686_image/: 8686.c
  group lwipport
    ../lwIP/port/: lwIP.c
    ../lwIP/port/netif/: ethernetif.c
  group lwip
    ../lwIP/src/netif/: etharp.c
    ../lwIP/src/core/: dhcp.c dhcpsrv.c dns.c init.c mem.c memp.c netbios.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../lwIP/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group netapp
    ../netapp/: netapp.c sample_http.c
  group src
    ../main/: main.c parmcfg.c xxxconfig.h
  group Document
    ../: ReadMe.txt
  group wpa_linux_plat
    ../wpa_supplicant-0.7.3/wpa_supplicant-0.7.3/wpa_supp_linux_plat/: wpa_supp_linux_plat.c
  group wpa_l2_packet
    ../wpa_supplicant-0.7.3/wpa_supplicant-0.7.3/src/l2_packet/: l2_packet_none.c
  group wpa_eapol_supp
    ../wpa_supplicant-0.7.3/wpa_supplicant-0.7.3/src/eapol_supp/: eapol_supp_sm.c
  group wpa_crypto
    ../wpa_supplicant-0.7.3/wpa_supplicant-0.7.3/src/crypto/: aes-cbc.c aes-ctr.c aes-encblock.c aes-wrap.c aes-unwrap.c aes-omac1.c aes-internal-enc.c aes-internal-dec.c aes-internal.c aes-eax.c md5-internal.c md5.c md4-internal.c sha1.c sha1-internal.c sha1-pbkdf2.c sha1-tlsprf.c sha1-tprf.c sha256.c sha256-internal.c fips_prf_cryptoapi.c crypto_internal-cipher.c des-internal.c rc4.c tls_none.c ms_funcs.c dh_groups.c
  group wpa_eapol_common
    ../wpa_supplicant-0.7.3/wpa_supplicant-0.7.3/src/eap_common/: eap_ikev2_common.c eap_pax_common.c eap_peap_common.c eap_psk_common.c eap_sake_common.c eap_sim_common.c eap_wsc_common.c ikev2_common.c chap.c eap_common.c eap_fast_common.c eap_gpsk_common.c
  group wpa_eap_peer
    ../wpa_supplicant-0.7.3/wpa_supplicant-0.7.3/src/eap_peer/: eap.c eap_aka.c eap_fast.c eap_fast_pac.c eap_gpsk.c eap_gtc.c eap_ikev2.c eap_leap.c eap_md5.c eap_methods.c eap_mschapv2.c eap_otp.c eap_pax.c eap_peap.c eap_psk.c eap_sake.c eap_sim.c eap_tls.c eap_tls_common.c eap_ttls.c eap_vendor_test.c ikev2.c mschapv2.c
  group wpa_driver
    ../wpa_supplicant-0.7.3/wpa_supplicant-0.7.3/src/drivers/: drivers.c driver_wext.c driver_none.c
  group yeelink
    ../netapp/: yeelink.c
