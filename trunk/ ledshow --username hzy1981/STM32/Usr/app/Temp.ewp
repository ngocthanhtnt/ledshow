# IAR project Temp.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  ICCARM.CCIncludePath2: Cfg\; Drv\; $PROJ_DIR$
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: Temp.srec
  ILINK.IlinkOutputFile: Temp.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\CONFIG\generic_cortex_test.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\generic_cortex_test.icf
  group (top)
    ./: Border_Show.cpp Border_Show.h Clock_Show.cpp Clock_Show.h com.cpp com.h File_Op.cpp File_Op.h Flash_Show.cpp Flash_Show.h Humidity_Show.cpp Humidity_Show.h Includes.h LED_Cfg.h LED_Para.cpp LED_Para.h LED_Scan.cpp LED_Show.cpp LED_Show.h Lun_Show.cpp Lun_Show.h main.cpp Main_Show.cpp Main_Show.h Noise_Show.cpp Noise_Show.h nongli.cpp nongli.h OS_Cfg.h OS_Core.cpp OS_Core.h OS_Event.cpp OS_Event.h OS_Ext.cpp OS_Ext.h OS_Includes.h OS_Mem.cpp OS_Mem.h OS_Msg.cpp OS_Msg.h OS_Msg_Q.cpp OS_Msg_Q.h OS_Mutex.cpp OS_Mutex.h OS_Port.cpp OS_Port.h OS_Port_a.asm OS_Pub.cpp OS_Pub.h OS_Sem.cpp OS_Sem.h OS_Shell.cpp OS_Shell.h OS_Time.cpp OS_Time.h Pic_Show.cpp Pic_Show.h pub.cpp pub.h QT_SIM.cpp QT_SIM.h Screen_Status.cpp Screen_Status.h Shell.cpp Shell.h STM32.cpp STM32.h Storage.cpp Storage.h Temp_Show.cpp Temp_Show.h Time_Show.cpp Time_Show.h Timer_Show.cpp Timer_Show.h ZK.cpp ZK.h
  group CFG
    Cfg/: LED_A0_Cfg.h LED_B0_Cfg.h LED_C0_Cfg.h LED_D0_Cfg.h LED_E0_Cfg.h
  group DRV
    Drv/: Led_A0_Drv.cpp Led_A0_Drv.h LED_B0_Drv.cpp LED_B0_Drv.h LED_C0_Drv.cpp LED_C0_Drv.h LED_D0_Drv.cpp LED_D0_Drv.h LED_E0_Drv.cpp LED_E0_Drv.h
