# Keil uVision project Project.uvproj, settings and files
target A (ARM-ADS)
  device: STM32F100C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: A
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD,CARD_A
  c include: ..\;..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\STM32100E_EVAL;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Usr\app;..\..\..\Usr\cfg;..\..\..\Usr\drv;..\..\..\Libraries\STM32_USB_HOST_Driver\inc;..\..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc;..\..\..\Libraries\STM32_USB_HOST_Library\Core\inc;..\..\..\Utilities\Third_Party\efsl\inc;..\..\..\Libraries\STM32_USB_HOST_Library\Class\HID\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\A\A.sct
  group StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_spi.c stm32f10x_fsmc.c stm32f10x_usart.c stm32f10x_sdio.c stm32f10x_dma.c stm32f10x_i2c.c stm32f10x_flash.c stm32f10x_pwr.c stm32f10x_tim.c misc.c stm32f10x_iwdg.c stm32f10x_bkp.c stm32f10x_adc.c stm32f10x_crc.c
  group CMSIS
    ../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../: system_stm32f10x.c
  group MDK-ARM
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_hd_vl.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md_vl.s startup_stm32f10x_xl.s
  group Doc
    ./: readme.txt
  group Cfg
    ../../../Usr/cfg/: LED_CX_Cfg.h LED_DX_Cfg.h LED_EX_Cfg.h LED_ABX_Cfg.h LED_CWX_Cfg.h
  group APP
    ../../../Usr/app/: ZK.c Border_Show.c Clock_Show.c com.c Flash_Show.c Humidity_Show.c LED_Para.c LED_Scan.c LED_Show.c Lun_Show.c main.c Main_Show.c Net_Proc.c Noise_Show.c nongli.c OS_Pub.c Pic_Show.c pub.c Screen_Status.c Shell.c Storage.c Temp_Show.c Time_Show.c Timer_Show.c UDisk_Proc.c ZK.h Border_Show.h Clock_Show.h com.h Flash_Show.h Humidity_Show.h Includes.h LED_Cfg.h LED_Para.h LED_Show.h Lun_Show.h Main_Show.h Net_Proc.h Noise_Show.h nongli.h OS_Cfg.h OS_Includes.h OS_Pub.h Pic_Show.h pub.h Screen_Status.h Shell.h Storage.h Temp_Show.h Time_Show.h Timer_Show.h UDisk_Proc.h OS_Port.h OS_Core.h OS_Shell.c OS_Shell.h LED_Scan.h OS_Time.c OS_Time.h OS_Core.c OS_Ext.h OS_Ext.c Txt_Show.c Txt_Show.h Sms.c Sms.h SMS_Show.c SMS_Show.h GB2UCS2.c
  group DRV
    ../../../Usr/drv/: CH376.c FILE_SYS.c spi_flash.c STM32.c stm32f10x_it.c CH376.H CH376INC.H FILE_SYS.H spi_flash.h STM32.h stm32f10x_conf.h stm32f10x_it.h DS1302.c DS1302.h LED_CX_Drv.c LED_DX_Drv.c LED_EX_Drv.c LED_CX_Drv.h LED_DX_Drv.h LED_EX_Drv.h Led_ABX_Drv.c Led_ABX_Drv.h usb_bsp.c usbh_usr.c enc28j60.c enc28j60.h Net_Config.c EMAC.C EMAC.H Net_Config.h SIM900A.h SIM900A.c LED_CWX_Drv.c LED_CWX_Drv.h SHT1X.c SHT1X.h DS18B20.c DS18B20.h Net_lib.c
  group LIB
    ../../../Usr/drv/: TCP_CM3.lib TCPD_CM3.lib
  group USB_CORE
    ../../../Libraries/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
    ../../../Libraries/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../../../Libraries/STM32_USB_HOST_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group FAT_FS
    ../../../Utilities/Third_Party/fat_fs/src/: fattime.c ff.c
target B (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: B +hex
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD,CARD_B
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8001000 size 0x1f000
  memory RVCT9: RAM 0x20000000 size 0x5000
target C (ARM-ADS)
  device: STM32F105RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: C +hex
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL,CARD_C
  c include: ..\;..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\STM32100E_EVAL;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Usr\app;..\..\..\Usr\cfg;..\..\..\Usr\drv;..\..\..\Libraries\STM32_USB_HOST_Driver\inc;..\..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc;..\..\..\Libraries\STM32_USB_HOST_Library\Core\inc;..\..\..\Libraries\STM32_USB_HOST_Library\Class\HID\inc;..\..\..\Utilities\Third_Party\fat_fs\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8001000 size 0x1f000
  memory RVCT9: RAM 0x20000000 size 0x8000
target D (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: D +hex
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD,CARD_D
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8001000 size 0x3f000
  memory RVCT9: RAM 0x20000000 size 0xc000
target CW (ARM-ADS)
  device: STM32F105RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: CW +hex
  c flags: oTime=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL,CARD_CW
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x38000
  memory RVCT9: RAM 0x20000000 size 0x10000
