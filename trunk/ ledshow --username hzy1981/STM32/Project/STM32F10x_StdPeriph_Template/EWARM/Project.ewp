# IAR project Project.ewp, settings and files
configuration STM32100B-EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F100xB ST STM32F100xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Usr\app; ..\..\..\Usr\drv; ..\..\..\Usr\cfg
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM3210C-EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
configuration STM3210E-EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
configuration STM3210B-EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
configuration STM32100E-EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F100xE ST STM32F100xE
configuration STM3210E-EVAL_XL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xxG ST STM32F10xxG
  group CMSIS
    ../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../: system_stm32f10x.c
  group Doc
    ./: readme.txt
  group EWARMv5
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_hd_vl.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md.s startup_stm32f10x_md_vl.s startup_stm32f10x_xl.s
  group StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User/App
    ../../../Usr/app/: Border_Show.cpp Border_Show.h Clock_Show.cpp Clock_Show.h com.cpp com.h File_Op.cpp File_Op.h Flash_Show.cpp Flash_Show.h Humidity_Show.cpp Humidity_Show.h Includes.h LED_Cfg.h LED_Para.cpp LED_Para.h LED_Scan.cpp LED_Show.cpp LED_Show.h LED_Show_Proc.h Lun_Show.cpp Lun_Show.h main.cpp Main_Show.cpp Main_Show.h Noise_Show.cpp Noise_Show.h nongli.cpp nongli.h OS_Cfg.h OS_Core.cpp OS_Core.h OS_Event.cpp OS_Event.h OS_Ext.cpp OS_Ext.h OS_Includes.h OS_Mem.cpp OS_Mem.h OS_Msg.cpp OS_Msg.h OS_Msg_Q.cpp OS_Msg_Q.h OS_Mutex.cpp OS_Mutex.h OS_Port.cpp OS_Port.h OS_Port_a.asm OS_Pub.cpp OS_Pub.h OS_Sem.cpp OS_Sem.h OS_Shell.cpp OS_Shell.h OS_Time.cpp OS_Time.h Pic_Show.cpp Pic_Show.h pub.cpp pub.h Screen_Status.cpp Screen_Status.h Shell.cpp Shell.h STM32.cpp STM32.h Storage.cpp Storage.h Temp_Show.cpp Temp_Show.h Time_Show.cpp Time_Show.h Timer_Show.cpp Timer_Show.h ZK.cpp ZK.h
  group User/Cfg
    ../../../Usr/cfg/: LED_A0_Cfg.h LED_B0_Cfg.h LED_C0_Cfg.h LED_D0_Cfg.h LED_E0_Cfg.h
  group User/Drv
    ../../../Usr/drv/: CH376.C CH376.H CH376INC.H FILE_SYS.C FILE_SYS.H Led_A0_Drv.cpp LED_A0_Drv.h LED_B0_Drv.cpp LED_B0_Drv.h LED_C0_Drv.cpp LED_C0_Drv.h LED_D0_Drv.cpp LED_D0_Drv.h LED_E0_Drv.cpp LED_E0_Drv.h USART.c USART.h
